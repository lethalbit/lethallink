# Repository lethalbit/lethallink (continued)

## KiCad design hardware/boards/host_card/lethallink.kicad_pcb (continued)

Parts:
U1: ECP5UM5G-381caBGA; 318caBGA; MPN LFE5UM5G-85F-8BG381I; DIGIKEY_PN 220-2112-ND

Connections:
/AUX Control/CLKREQ#: U1.G2 (PL47A); also elsewhere on the board
/AUX Control/PCIe_SMCLK: U1.J3 (PL50C); also elsewhere on the board
/AUX Control/PCIe_SMDAT: U1.J5 (PL50B); also elsewhere on the board
/AUX Control/PCIe_TCK: U1.K4 (PL56A); also elsewhere on the board
/AUX Control/PCIe_TDI: U1.L4 (PL56C); also elsewhere on the board
/AUX Control/PCIe_TDO: U1.M4 (PL83A); also elsewhere on the board
/AUX Control/PCIe_TMS: U1.N2 (PL89A); also elsewhere on the board
/AUX Control/PCIe_TRST#: U1.G1 (PL47D); also elsewhere on the board
/AUX Control/PERST#: U1.H2 (PL47C); also elsewhere on the board
/AUX Control/WAKE#: U1.F1 (PL47B); also elsewhere on the board

Parts:
C66, C67, C68, C69, C70, C71, C72, C73, C75, C76: 0.1uF; C_0402_1005Metric; MPN C0402C104M8PACTU
R60, R61: 100; R_0402_1005Metric; MPN RCS0402100RFKED
U1: ECP5UM5G-381caBGA; 318caBGA
U7: SI5330B; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm; MPN SI5330B-B00205-GM

Connections:
/PCIe Interface/REFCLK0+: R60.1, U1.Y11 (REFCLK_D0_P), U7.14 (CLK2+)
/PCIe Interface/REFCLK0-: R60.2, U1.Y12 (REFCLK_D0_N), U7.13 (CLK2-)
/PCIe Interface/REFCLK1+: R61.1, U1.Y19 (REFCLK_D1_P), U7.10 (CLK3+)
/PCIe Interface/REFCLK1-: R61.2, U1.W20 (REFCLK_D1_N), U7.9 (CLK3-)
/PCIe Interface/REFCLK+: C76.2, U7.1 (IN1)
/PCIe Interface/REFCLK-: C75.2, U7.2 (IN2)
/PCIe Interface/REFCLK_N: C75.1; also elsewhere on the board
/PCIe Interface/REFCLK_P: C76.1; also elsewhere on the board
/PCIe Interface/RX0+: C66.2, U1.W4 (D0CH0_HDTX0_P)
/PCIe Interface/RX0-: C68.2, U1.W5 (D0CH0_HDTX0_N)
/PCIe Interface/RX0_N: C68.1; also elsewhere on the board
/PCIe Interface/RX0_P: C66.1; also elsewhere on the board
/PCIe Interface/RX1+: C73.2, U1.W8 (D0CH1_HDTX0_P)
/PCIe Interface/RX1-: C71.2, U1.W9 (D0CH1_HDTX0_N)
/PCIe Interface/RX1_N: C71.1; also elsewhere on the board
/PCIe Interface/RX1_P: C73.1; also elsewhere on the board
/PCIe Interface/RX2+: C67.2, U1.W13 (D1CH0_HDTX0_P)
/PCIe Interface/RX2-: C69.2, U1.W14 (D1CH0_HDTX0_N)
/PCIe Interface/RX2_N: C69.1; also elsewhere on the board
/PCIe Interface/RX2_P: C67.1; also elsewhere on the board
/PCIe Interface/RX3+: C72.2, U1.W17 (D1CH1_HDTX0_P)
/PCIe Interface/RX3-: C70.2, U1.W18 (D1CH1_HDTX0_N)
/PCIe Interface/RX3_N: C70.1; also elsewhere on the board
/PCIe Interface/RX3_P: C72.1; also elsewhere on the board
/PCIe Interface/TX0_N: U1.Y6 (D0CH0_HDRX0_N); also elsewhere on the board
/PCIe Interface/TX0_P: U1.Y5 (D0CH0_HDRX0_P); also elsewhere on the board
/PCIe Interface/TX1_N: U1.Y8 (D0CH1_HDRX0_N); also elsewhere on the board
/PCIe Interface/TX1_P: U1.Y7 (D0CH1_HDRX0_P); also elsewhere on the board
/PCIe Interface/TX2_N: U1.Y15 (D1CH0_HDRX0_N); also elsewhere on the board
/PCIe Interface/TX2_P: U1.Y14 (D1CH0_HDRX0_P); also elsewhere on the board
/PCIe Interface/TX3_N: U1.Y17 (D1CH1_HDRX0_N); also elsewhere on the board
/PCIe Interface/TX3_P: U1.Y16 (D1CH1_HDRX0_P); also elsewhere on the board
GND: U7.3 (IN3); also elsewhere on the board

Schematic: DDR3Cache.sch, lethallink

Parts:
C74: 0.1uF; C_0603_1608Metric; MPN C0603C104M5RACTU
C83: 10nF; C_0402_1005Metric; MPN C0402C103M5RACTU
R8, R36: 50; R_0402_1005Metric; MPN FC0402E50R0BST1
R37, R62: 240; R_0603_1608Metric; MPN RNCF0603TKY250R
R58: 100; R_0402_1005Metric; MPN RCS0402100RFKED
U1: ECP5UM5G-381caBGA; 318caBGA; MPN LFE5UM5G-85F-8BG381I; DIGIKEY_PN 220-2112-ND
U4, U8: IS43TR16256B-125KBL; BGA-96_9.0x13.0mm_Layout2x3x16_P0.8mm; MPN IS43TR16256B-125KBL
X2: 100MHz; AX3; MPN AX3DCF1-100.0000

Connections:
/Boot Config/FPGA_DONE: U4.T2 (~RESET), U8.T2 (~RESET); also elsewhere on the board
/DDR3 Cache/A0: U1.K20 (PR44D), U4.N3 (A0), U8.N3 (A0)
/DDR3 Cache/A1: U1.J20 (PR44C), U4.P7 (A1), U8.P7 (A1)
/DDR3 Cache/A2: U1.K19 (PR44B), U4.P3 (A2), U8.P3 (A2)
/DDR3 Cache/A3: U1.J19 (PR44A), U4.N2 (A3), U8.N2 (A3)
/DDR3 Cache/A4: U1.K18 (PR41D), U4.P8 (A4), U8.P8 (A4)
/DDR3 Cache/A5: U1.F20 (PR38C), U4.P2 (A5), U8.P2 (A5)
/DDR3 Cache/A6: U1.K16 (PR29A), U4.R8 (A6), U8.R8 (A6)
/DDR3 Cache/A7: U1.J16 (PR20D), U4.R2 (A7), U8.R2 (A7)
/DDR3 Cache/A8: U1.J17 (PR20C), U4.T8 (A8), U8.T8 (A8)
/DDR3 Cache/A9: U1.H17 (PR20B), U4.R3 (A9), U8.R3 (A9)
/DDR3 Cache/A10: U1.H18 (PR20A), U4.L7 (A10/AP), U8.L7 (A10/AP)
/DDR3 Cache/A11: U1.H16 (PR17D), U4.R7 (A11), U8.R7 (A11)
/DDR3 Cache/A12: U1.G16 (PR17C), U4.N7 (A12/~BC), U8.N7 (A12/~BC)
/DDR3 Cache/A13: U1.G18 (PR17B), U4.T3 (A13), U8.T3 (A13)
/DDR3 Cache/A14: U1.F17 (PR17A), U4.T7 (A14), U8.T7 (A14)
/DDR3 Cache/A15: U1.F18 (PR14D), U4.M7 (A15/NC), U8.M7 (A15/NC)
/DDR3 Cache/BA0: U1.K17 (PR29B), U4.M2 (BA0), U8.M2 (BA0)
/DDR3 Cache/BA1: U1.C20 (PR35A), U4.N8 (BA1), U8.N8 (BA1)
/DDR3 Cache/BA2: U1.D19 (PR35B), U4.M3 (BA2), U8.M3 (BA2)
/DDR3 Cache/CK+: R8.1, U1.G19 (PR41A), U4.J7 (CK), U8.J7 (CK)
/DDR3 Cache/CK-: R36.1, U1.H20 (PR41B), U4.K7 (~CK), U8.K7 (~CK)
/DDR3 Cache/CKE0: U1.F19 (PR38B), U4.K9 (CKE)
/DDR3 Cache/CKE1: U1.G20 (PR38D), U8.K9 (CKE)
/DDR3 Cache/CLK+: R58.1, U1.L20 (PR47A), X2.4 (CLK)
/DDR3 Cache/CLK-: R58.2, U1.M20 (PR47B), X2.5 (~CLK)
/DDR3 Cache/DML0: U1.D17 (PR11B), U4.E7 (DML), U8.E7 (DML)
/DDR3 Cache/DMU0: U1.C18 (PR11A), U4.D3 (DMU), U8.D3 (DMU)
/DDR3 Cache/DQL0: U1.M19 (PR47D), U4.E3 (DQL0), U8.E3 (DQL0)
/DDR3 Cache/DQL1: U1.L16 (PR50A), U4.F7 (DQL1), U8.F7 (DQL1)
/DDR3 Cache/DQL2: U1.L18 (PR50C), U4.F2 (DQL2), U8.F2 (DQL2)
/DDR3 Cache/DQL3: U1.M18 (PR50D), U4.F8 (DQL3), U8.F8 (DQL3)
/DDR3 Cache/DQL4: U1.N18 (PR53C), U4.H3 (DQL4), U8.H3 (DQL4)
/DDR3 Cache/DQL5: U1.N17 (PR56A), U4.H8 (DQL5), U8.H8 (DQL5)
/DDR3 Cache/DQL6: U1.R17 (PR56D), U4.G2 (DQL6), U8.G2 (DQL6)
/DDR3 Cache/DQL7: U1.R16 (PR56C), U4.H7 (DQL7), U8.H7 (DQL7)
/DDR3 Cache/DQSL0+: U1.N16 (PR53A), U4.F3 (DQSL), U8.F3 (DQSL)
/DDR3 Cache/DQSL0-: U1.M17 (PR53B), U4.G3 (~DQSL), U8.G3 (~DQSL)
/DDR3 Cache/DQSU0+: U1.T19 (PR89A), U4.C7 (DQSU), U8.C7 (DQSU)
/DDR3 Cache/DQSU0-: U1.R18 (PR89B), U4.B7 (~DQSU), U8.B7 (~DQSU)
/DDR3 Cache/DQU0: U1.P19 (PR83C), U4.D7 (DQU0), U8.D7 (DQU0)
/DDR3 Cache/DQU1: U1.P18 (PR83D), U4.C3 (DQU1), U8.C3 (DQU1)
/DDR3 Cache/DQU2: U1.P20 (PR86A), U4.C8 (DQU2), U8.C8 (DQU2)
/DDR3 Cache/DQU3: U1.R20 (PR86B), U4.C2 (DQU3), U8.C2 (DQU3)
/DDR3 Cache/DQU4: U1.U20 (PR86D), U4.A7 (DQU4), U8.A7 (DQU4)
/DDR3 Cache/DQU5: U1.U19 (PR89C), U4.A2 (DQU5), U8.A2 (DQU5)
/DDR3 Cache/DQU6: U1.U18 (PR92A), U4.B8 (DQU6), U8.B8 (DQU6)
/DDR3 Cache/DQU7: U1.U17 (PR92B), U4.A3 (DQU7), U8.A3 (DQU7)
/DDR3 Cache/ODT0: U1.J18 (PR41C), U4.K1 (ODT)
/DDR3 Cache/ODT1: U1.T16 (PR77A), U8.K1 (ODT)
/DDR3 Cache/_1V8: C74.2, X2.1 (OE), X2.6 (VCC)
/DDR3 Cache/~CAS: U1.E19 (PR35D), U4.K3 (~CAS), U8.K3 (~CAS)
/DDR3 Cache/~CS0: U1.N19 (PR83A), U4.L2 (~CS)
/DDR3 Cache/~CS1: U1.N20 (PR83B), U8.L2 (~CS)
/DDR3 Cache/~RAS: U1.D20 (PR35C), U4.J3 (~RAS), U8.J3 (~RAS)
/DDR3 Cache/~WE: U1.E20 (PR38A), U4.L3 (~WE), U8.L3 (~WE)
GND: C74.1, C83.2, R37.2, R62.2, X2.3 (GND); also elsewhere on the board
unnamed: C83.1, R8.2, R36.2
unnamed: R37.1, U4.L8 (ZQ)
unnamed: R62.1, U8.L8 (ZQ)

Notes on the sheet:
~WE~ -> E20 ~RAS ~ -> D20 ODT1 -> T16 ODT0 -> J18 CKE1 -> G20 CKE0 -> F19 ~CAS ~ -> E19 BA2 -> D19 BA1 -> C20 BA0 -> K17 ADDR15 -> F18 ADDR14 -> F17 ADDR13 -> G18 ADDR12 -> G16 ADDR11 -> H16 ADDR10 -> H18 ADDR9 -> H17 ADDR8 -> J17 ADDR7 -> J16 ADDR6 -> K16 ADDR5 -> F20 ADDR4 -> K18 ADDR3 -> J19 ADD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
As Divined By Lattice Diamond
TODO: DDR3 Termination

Schematic: BootConfig.sch, lethallink

Parts:
C54: 0.1uF; C_0603_1608Metric; MPN C0603C104M5RACTU
C55, C56: 15pF; C_0603_1608Metric; MPN C0603C150J5GACTU
D8: BLU; LED_0603_1608Metric; MPN 150060BS75000
D9: RED; LED_0603_1608Metric; MPN 150060RS75000
D10: PNK; LED_0603_1608Metric; MPN OSK40603C1E
J3: Conn_02x05_Odd_Even; FTSH-105-01-L-DV-K-TR; MPN FTSH-105-01-L-DV-K-TR
J4: Conn_02x04_Odd_Even; FTSH-105-01-L-DV-K-TR; MPN FTSH-105-01-L-DV-K-TR
J7: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
Q6, Q7: Q_NMOS_GSD; SOT-23; MPN DMN65D8L-7
R9: 1k; R_0603_1608Metric; MPN CRCW06031K00FKEAHP
R38, R39, R40, R41, R43, R44, R45, R46, R48, R49, R50, R51, R54: 10k; R_0603_1608Metric; MPN CRCW060310K0FKEA
R42: 50; R_0603_1608Metric; MPN CRCW060350R0FKEA
R47: 4k7; R_0603_1608Metric; MPN RCS06034K70FKEA
R52: 6k04; R_0603_1608Metric; MPN RCS06036K04FKEA
R53: 200; R_0603_1608Metric; MPN RCS0603200RFKEA
R55: 1k; R_0402_1005Metric; MPN RCS04021K00FKED
SW2: RESET; SW_Push_1P1T_NO_CK_KMR2; MPN KMR241NG ULC LFS
U1: ECP5UM5G-381caBGA; 318caBGA; MPN LFE5UM5G-85F-8BG381I; DIGIKEY_PN 220-2112-ND
U3: CYUSB3014; BGA-121_11x11_10.0x10.0mm; MPN CYUSB3014-BZXI; DIGIKEY_PN 428-3130-ND
U5: 128MiB; WSON-8-1EP-6.0x8.0mm; MPN W25N01GVZEIG TR
Y1: 19.2MHz; Crystal_SMD_Abracon_ABM10-4Pin_2.5x2.0mm; MPN ABM10-19.200MHZ-D30-T3

Connections:
+1V8: R55.1; also elsewhere on the board
+3V3: J3.1, J4.4, R9.1, R38.1, R39.1, R40.1, R41.1, R43.1, R44.1, R45.1, R46.1, R47.1, R48.1, R50.1, R51.1; also elsewhere on the board
/Boot Config/FPGA_CLK: J7.7; also elsewhere on the board
/Boot Config/FPGA_DI: J7.5; also elsewhere on the board
/Boot Config/FPGA_DO: J7.3; also elsewhere on the board
/Boot Config/FPGA_DONE: R49.2, U1.Y3 (DONE); also elsewhere on the board
/Boot Config/FPGA_TDO: U1.V4 (TDO), U3.E7 (TDI)
/Boot Config/TCK: J3.4, R39.2, U1.T5 (TCK), U3.F6 (TCK)
/Boot Config/TDI: J3.8, R41.2, U1.R5 (TDI)
/Boot Config/TDO: J3.6, R40.2, U3.C10 (TDO)
/Boot Config/TMS: J3.2, R38.2, U1.U5 (TMS), U3.E8 (TMS)
/Boot Config/XTAL+: C56.2, U3.C6 (XTAL_IN), Y1.3
/Boot Config/XTAL-: C55.2, U3.C7 (XTAL_OUT), Y1.1
/Boot Config/~FPGA_CS: J7.1; also elsewhere on the board
/Boot Config/~INIT: D9.1 (K), J4.1, U1.V3 (~INIT)
/Boot Config/~PHY_INT: U3.L8 (INT#); also elsewhere on the board
/Boot Config/~PHY_RESET: R54.1, U1.T3 (PB18A/WRITEN); also elsewhere on the board
/Boot Config/~RESET: C54.2, D10.1 (K), J3.10, J4.2, R50.2, SW2.1, U1.W3 (~PROGRAM), U3.B11 (TRST#)
GND: C54.1, C55.1, C56.1, J3.3, J3.5, J3.9, J4.3, Q6.2 (S), Q7.2 (S), R52.2, R53.2, SW2.2, U1.R4 (CFG_2), U1.U4 (CFG_0), U3.B2 (FSLC[0]), U3.B4 (FSLC[1]), U3.E6 (FSLC[2]), Y1.2, Y1.4; also elsewhere on the board
unnamed: D8.1 (K), Q6.3 (D)
unnamed: D8.2 (A), R47.2
unnamed: D9.2 (A), R48.2
unnamed: D10.2 (A), R51.2
unnamed: J4.5, J7.6, R46.2, U1.V2 (PB11A/D1/MISO/IO1), U5.5 (DI/IO0)
unnamed: J4.6, R43.2, U1.Y2 (PB9B/D2/IO2), U5.3 (~WP~/IO2)
unnamed: J4.7, J7.8, R42.1, U5.6 (CLK)
unnamed: J4.8, J7.4, R44.2, U1.W2 (PB11B/D0/MOSI/IO2), U5.2 (DO/IO1)
unnamed: J4.9, R45.2, U1.W1 (PB9A/D3/IO3), U5.7 (~HOLD~/IO3)
unnamed: J4.10, J7.2, U1.R2 (PB15A/HOLDN/DI/BUSY/CSSPIN/CEN), U5.1 (~CS)
unnamed: Q6.1 (G), R49.1
unnamed: Q7.1 (G), R54.2
unnamed: Q7.3 (D), R55.2, U3.C5 (RESET#)
unnamed: R9.2, U1.T4 (CFG_1)
unnamed: R42.2, U1.U3 (CCLK)
unnamed: R52.1, U3.C8 (R_USB2)
unnamed: R53.1, U3.B3 (R_USB3)

Notes on the sheet:
CFG[0..2] should be 0 1 0 for SPI primary.
I *think* this is correct?
SWD/JTAG Pinout: 01 - 3v3 02 - TMS 03 - GND 04 - TCK 05 - GND 06 - TDO 07 - NC 08 - TDI 09 - GND 10 - ~PROGRAM/RESET
FSLC[0..2] Set to 0 0 0 for 19.2MHz Crystal input.
SPI Flash Pinout 01 - ~INIT~ 02 - ~PROGRAM~ 03 - GND 04 - 3v3 05 - DI/IO0 06 - ~WP~/IO2 07 - CLK 08 - DO/IO1 09 - ~HOLD~/IO3 10 - ~CS~
FPGA SPI flash USB PHY jumper. Close to enable DFU for gateware

Schematic: USB3Interface.sch, lethallink

Parts:
C39: 0.1uF; C_0603_1608Metric; MPN C0603C104M5RACTU
C77, C78: 0.1uF; C_0402_1005Metric; MPN C0402C104M8PACTU
D11: RClamp3324P; MPN RCLAMP3324P.TNT
D12: RClamp0512; MPN RCLAMP0512TQTCT
J2: USB3_Micro_B_Amphenol; MPN GSB343K33HR; DIGIKEY_PN GSB343K33HRCT-ND
J5: Conn_02x04_Odd_Even; FTSH-105-01-L-DV-K-TR; MPN FTSH-105-01-L-DV-K-TR
R35: 1M; R_0603_1608Metric; MPN CRCW06031M00FKEA
R59: 1k; R_0402_1005Metric; MPN RCS04021K00FKED
U1: ECP5UM5G-381caBGA; 318caBGA; MPN LFE5UM5G-85F-8BG381I; DIGIKEY_PN 220-2112-ND
U3: CYUSB3014; BGA-121_11x11_10.0x10.0mm; MPN CYUSB3014-BZXI; DIGIKEY_PN 428-3130-ND
U6: 128MiB; WSON-8-1EP-6.0x8.0mm; MPN W25N01GVZEIG

Connections:
+1V8: R59.1; also elsewhere on the board
+3V3: J5.4; also elsewhere on the board
/Boot Config/FPGA_CLK: J5.7, U3.D4 (GPIO[53]), U6.6 (CLK); also elsewhere on the board
/Boot Config/FPGA_DI: J5.5, U3.D5 (GPIO[56]), U6.5 (DI/IO0); also elsewhere on the board
/Boot Config/FPGA_DO: J5.8, U3.C2 (GPIO[55]), U6.2 (DO/IO1); also elsewhere on the board
/Boot Config/~FPGA_CS: U3.C4 (GPIO[57]); also elsewhere on the board
/Boot Config/~PHY_INT: U1.D2 (PL38C); also elsewhere on the board
/Boot Config/~PHY_RESET: J5.2; also elsewhere on the board
/IC Power/VBUS: J2.1 (VBUS); also elsewhere on the board
/USB3 Interface/ALE: U1.E1 (PL38D), U3.K5 (GPIO[27])
/USB3 Interface/D+: D12.2, J2.3 (D_P), U3.A9 (D_P)
/USB3 Interface/D-: D12.1, J2.2 (D_N), U3.A10 (D_N)
/USB3 Interface/DQ0: U1.A4 (PL11A), U3.F10 (GPIO[00])
/USB3 Interface/DQ1: U1.C5 (PL11D), U3.F9 (GPIO[01])
/USB3 Interface/DQ2: U1.E4 (PL17A), U3.F7 (GPIO[02])
/USB3 Interface/DQ3: U1.B4 (PL14B), U3.G10 (GPIO[03])
/USB3 Interface/DQ4: U1.D5 (PL17B), U3.G9 (GPIO[04])
/USB3 Interface/DQ5: U1.C3 (PL17C), U3.F8 (GPIO[05])
/USB3 Interface/DQ6: U1.A3 (PL14C), U3.H10 (GPIO[06])
/USB3 Interface/DQ7: U1.C4 (PL14A), U3.H9 (GPIO[07])
/USB3 Interface/DQ8: U1.B3 (PL14D), U3.J10 (GPIO[08])
/USB3 Interface/DQ9: U1.C1 (PL38A), U3.J9 (GPIO[09])
/USB3 Interface/DQ10: U1.A2 (PL35A), U3.K11 (GPIO[10])
/USB3 Interface/DQ11: U1.B1 (PL35B), U3.L10 (GPIO[11])
/USB3 Interface/DQ12: U1.B2 (PL35C), U3.K10 (GPIO[12])
/USB3 Interface/DQ13: U1.C2 (PL35D), U3.K9 (GPIO[13])
/USB3 Interface/DQ14: U1.E3 (PL20B), U3.J8 (GPIO[14])
/USB3 Interface/DQ15: U1.D3 (PL17D), U3.G8 (GPIO[15])
/USB3 Interface/OE: U1.E2 (PL44D), U3.J7 (GPIO[19])
/USB3 Interface/PMODE_0: R59.2, U3.G4 (GPIO[30])
/USB3 Interface/PMODE_1: U3.H4 (GPIO[31])
/USB3 Interface/PSSTX+: C77.1, U3.A5 (SSTX_P)
/USB3 Interface/PSSTX-: C78.1, U3.A6 (SSTX_N)
/USB3 Interface/SSRX+: D11.2, J2.7 (SSTX_P), U3.A4 (SSRX_P)
/USB3 Interface/SSRX-: D11.1, J2.6 (SSTX_N), U3.A3 (SSRX_N)
/USB3 Interface/SSTX+: C77.2, D11.4, J2.10 (SSRX_P)
/USB3 Interface/SSTX-: C78.2, D11.3, J2.9 (SSRX_N)
/USB3 Interface/WE_D: U1.D1 (PL38B), U3.K7 (GPIO[18])
GND: C39.1, D11.GND, D12.GND, J2.5 (GND), J2.8 (GND), J5.1, J5.3, R35.2, U3.L4 (GPIO[32]); also elsewhere on the board
unnamed: C39.2, J2.11 (SHEILD), R35.1
unnamed: J5.6, U6.3 (~WP~/IO2)
unnamed: J5.9, U6.7 (~HOLD~/IO3)
unnamed: J5.10, U3.C1 (GPIO[54]), U6.1 (~CS)

Notes on the sheet:
SPI Flash Pinout 01 - GND 02 - ~PHY_RESET~ 03 - GND 04 - 3v3 05 - DI/IO0 06 - ~WP~/IO2 07 - CLK 08 - DO/IO1 09 - ~HOLD~/IO3 10 - ~CS~
PHY Boot config 0 0 X - Sync ADMux 1 0 X - Async ADMux 1 1 X - USB 1 X 0 - SPI, USB On failure

Board: 6 copper layers, 207.2 x 111.1 mm, 231 parts (75 on the bottom side), 237 nets.

## Commit log

2020-05-31 Added some additional default options
2020-05-31 Some initial work on the PCB, getting things basically set up
2020-05-31 Added and hooked up the nested schematic for the FPGA PCIe interface
2020-06-01 Added some more schematics for blocking things out, and tweaked the GND fingers on the PCIe edge a bit
2020-06-01 Added some eye-candy to the PCB
2020-06-01 Updated gitignore to exclude the bak files
2020-06-01 Removed sch bak files
2020-06-02 A bit of work on the power supply, the values still need to be calculated, but all the passives and such should be there
2020-06-03 Updated part mfr and added the proper part numbers
2020-06-03 Did some annotation and fixed the FPGA bank that was accidentally labled as the cypress part
2020-06-03 Cleaned up the schematic a bit more
2020-06-05 Some initial template setup for nMigen
2020-06-05 Some more mist schematic edits
2020-06-06 Lots of small updates, getting values specified for parts, switched the BJT to NFETs
2020-06-06 Added the proper part for the +12V LED resistor
2020-06-11 Updated the TODO list
2020-06-11 Added some more items to the todo list
2020-06-11 Updated the README with some basic information
2020-06-11 flipped ome parts to clean up how the lables were placed
2020-06-14 Updated the powersupply and schematic frames. Ran all the numbers for the passives for the supply
2020-06-14 Updated the TODO list again
2020-06-14 Populated most of the values for the powersupply
2020-06-14 Some strugglebusting on getting the ERC errors cleaned up a bit
2020-06-14 Some more ERC cleanup
2020-06-14 Switched out the inductor footprints to ones that now have 3d models
2020-06-14 Added the Mechanical and Graphics schematic
2020-06-14 Imported the parts onto the board, and group things roughly by functional group in preperation to route
2020-06-14 Updated TODO, added item to find USB ESD protection diodes
2020-06-14 Upped the schematic frame size from A4 to A3 to allow for some more breathing room, it was getting stuff in the powersupply schematic
2020-06-14 Pulled the schematic updates into the PCB
2020-06-14 Updated TODO with notes about FPGA bring-up
2020-06-14 Updated the schematics and PCB to bring the initial bootup config DIP switch for the FPGA into it and also ensured that the FPGA had VCCIO8 tied to 3v3 for proper config voltages
2020-06-14 Added the DDR3 Module
2020-06-14 Updated TODO list with the DDR3 Part item completed
2020-06-14 Updated TODO list with the items for the SPI flash and the DRAM
2020-06-14 Added the SPI Flash for the gateware, softcore firmware, and USB controller firmware, all the firmware really.
2020-06-14 Got a fair bit of the initial layout done for the power supply
2020-06-14 Upped the priority on the PSU pours to prevent them from getting drowned by the board-wide gnd pours
2020-06-15 Some more routing and placing of the PSU, lots to do still but it's progressing nicely
2020-06-15 Lots more place and routing done for the power supply, only the feeback and enable voltage deviders left to go, along with joining the two halfs with a common +12v pour
2020-06-15 Completed the PSU routing, not happy with some of the traces, might want to swap channels 3 and 4 to make the power-on sequence a bit better in terms of traces needing to be run
2020-06-15 Moved the powersupply into what should be its final home
2020-06-15 Updated TODO: marked the powersupply routing as completed
2020-06-15 Fixed the revision numbers
2020-06-15 Playing around with some of the PCIe power input stuff, not happy with it, I'll rip it up and try again some other time
2020-06-15 Moving some things around trying to figure out where they should roughly go, Also added some isolated earth pours for the USB sheild
2020-06-15 Added test points for the various voltage rails
2020-06-16 In an AHDH fuled stupor I made a bunch of changes, only the last of which I recall, which would be adding fiducials
2020-06-16 Added some basic pour keepouts to help manage the pours under the BGA parts
2020-06-16 Added the data and address buses for the DDR
2020-06-16 Spent a bit of time putting the unrouted parts back on-grid
2020-06-16 Worked on a bit of the power side for the DDR3 Cache
2020-06-16 Fixed the name of the DDR3 cache schematic, as we're not using LPDDR3
2020-06-16 Added the JTAG header and some misc cleanup
2020-06-16 Added a secondary SPI flash for the USB PHY Firmware. Yes it's overkill but it'll be fine. I'll use it to like, store configuration data or something
2020-06-16 Updates to the SPI flash
2020-06-16 Re-did the keepout for the top pour under the ram
2020-06-17 Updated gitignore
2020-06-17 Added a bunch of stuff having to do with JTAG and the FPGA flash / bring up
2020-06-17 Some ERC cleanup
2020-06-17 Added a debounce cap to the reset switch, as well as selected the reset switch itself, also added the needed pull-down resistors for the USB PHY
2020-06-17 Added the crystal for the USB PHY
2020-06-17 Annotated the schematics and updated the PCB with the new imported parts
2020-06-17 Added the 3D model to the crystal
2020-06-17 Added the power hookups for the USB PHY
2020-06-17 Resized some nested schematics and pulled the GPIF II interrupt line out from the boot config block into the USB 3 interface
2020-06-17 Updated the PCB with the new parts for PHY reset logic and added another fiducial for the other SPI flash
2020-06-17 Updated TODO with information regarding the LED resistors
2020-06-17 Added headers for the SPI flash for both the FPGA and the PHY
2020-06-17 Fixed the VIO4 rail of the USB PHY to be 3v3 not 1v8
2020-06-17 Added the main OSC for the FPGA
2020-06-17 Hooked up most of the GPIF II bus to the the FPGA
2020-06-17 Moved the power supply around and poked some of the IC lables
2020-06-17 Added a clock fanout buffer for the PCIe REFCLOCK to connect to the FPGAs SERDES banks
2020-06-18 Named the diff-pair clock nets
2020-06-18 Added missing bypass caps for the VCCO rails for the clock buffer
2020-06-18 Fixed up the clearences on the pours
2020-06-18 Connected the PCIe lanes to the FPGA SERDES channels
2020-06-18 Moving banks around and rotated the FPGA to try and give the SERDES channels the best routing to the PCIe connector
2020-06-18 Some strugglebusting with the DDR interface
2020-06-18 Moved some things around swapping the DDR from banks 7 and 8 to banks 2 and 3, and moved the GPIFF 2 stuff to bank 7 to stop them from crossing over
2020-06-18 Moved some more banks around to try and keeps things from crossing over as much as possible
2020-06-18 A batch of misc changes, I don't exactly recall what changed
2020-06-18 Updated TODO
2020-06-18 Some messing about with the GPIF interface
2020-06-19 Added the debug module connector (SODIMM 260), it's not hooked up to anything yet
2020-06-19 Moved the host card board files into its own subdirectory to allow for the debug modules to also be in the boards / gerbers directory without a massive mess
2020-06-19 More fiddling with the DM stuff
2020-06-19 Expanded the board length to 254mm and fixed the ground pours. thinking expanding the DM module length to 80 mm
2020-06-19 Added some initial documentation about debug modules
2020-06-19 Updated the generic SODIMM part footprint to use the new Debug Module footprint
2020-06-19 Updated the gitignore for solvespace temp files
2020-06-19 Some small updates to the debug module docs
2020-06-19 Updated the image in the debug module documentation
2020-06-19 Updated the solvespace cad file for the debug module and added a prelim pin table
2020-06-19 Fixed the pin table
2020-06-19 Some updates with the debug module interface
2020-06-19 Moved the mounting holes from 4.5mm to 4mm from the edges
2020-06-19 Added the debug module board footprint and the mount footprint to the lethallink eda libraries for KiCad
2020-06-20 Added the debug modules footprints
2020-06-21 Updates the clearences so I can actually route signals around and outside of the BGA packages.
2020-06-21 Re-routed the PCIe power input side of things to make it not such a massive mess
2020-06-21 Hooked up the 12v0 lines from the PCIe connector to the power supply
2020-06-21 Routed the PCIe TX and RX lines + wiggles, activly routing the clock
2020-06-21 Completed the layout for the PCIe REFCLK buffer and ensured the REFCLK traces were not skewed and that they are wiggled properly
2020-06-21 Added a fiducial to for U7. Changed the two pin-headers to the keyd samtec connectors. Some other misc updates
2020-06-21 Fixed up the consistancy of value naming, 100nF -> 0.1uF. Added the caps for the USB SSRX lines, moved the Ferrite for VBUS to fix a net naming issue
2020-06-22 Messing with the settings to try to allow for the minimal ammount of DRC violations needed to escape the large BGA package
2020-06-23 Re-routed the USB side of things after adding the ESD diodes for the USB SS lines, still need to add the diode for the normal D+/D- pair
2020-06-24 Added another DDR3 module to expand cache to 8GiB
2020-06-24 Fixed the pour keepout for the DDR3 modules
2020-06-24 Fixed the missing address lines from the second DRAM module
2020-06-24 Some more messing about with the DDR3 modules
2020-06-25 Moving some things around in the DDR3 cache schematic
2020-06-25 Added the last ESD diode for the USB D+/D- lines
2020-06-25 Roughly grouped unplaced parts together based on what they are related to
2020-06-25 Added a pin-header for the FPGA SPI flash lines to allow for the USB PHY to do a DFU update of the gateware when closed
2020-06-25 Hooked up the PCIe SMBUS and JTAG lines to the FPGA, might need to shuffle the signals around a little bit to get it to route nicely
2020-06-25 Added the remainder of the PCIe aux signals to the FPGA
2020-06-25 Updated the SPI flash footprints to have the exposed pad joined to the gnd properly
2020-06-26 Started poking the SPI flash for the USB PHY
2020-07-05 Some updates with the DDR3, gonna need to re-assign most of the pins to make routing it not a massive pain in the ass
2020-07-05 Fixed / updated the ECP5 symbol for the ECP5UM5G-85K
2020-07-05 Fixed the missing bus connections to the FPGA for the USB3 PHY, and updated the PCB
2020-07-05 Swizzled the pins on the PHY bus to make routing to the FPGA nicer, also did the initial bus routing
2020-07-05 Wiggling traces is hard
2020-07-05 Created a suggested via layout for routing out the Cypress USB3 PHY
2020-07-05 Fixed some traces that were munged w/ the PR
2020-07-05 Wiggled all the top traces that needed a good wiggling
2020-07-26 Lots of updates from a while ago, don't recall what's changed
2020-08-23 Broke out the DDR3 modules and added the 0.75V LDO for the VREFCA and VREFDQ lines for each of the DDR3 modules
2020-08-24 Minor cleanup and added some notes
2020-09-06 Implemented the primary 1.2V FPGA power decoupling caps
2020-09-07 Commited unholy DDR3 routing crimes
