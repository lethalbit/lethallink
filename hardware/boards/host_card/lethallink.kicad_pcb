# Repository lethalbit/lethallink

File README.md:

# lethallink

lethallink is a PCI-Express DMA engine with on board debugging machinery designed in an attempt to allow for mostly transparent access to a system under test with no software at all running on said system.

All of the information is exfiltrated onto a control system that can then be used for analysis. The control system can also interact with lethallink to add things like memory watchpoints via the control software or GDB integration. 

## Licenses

The lethallink project is licensed under 3 individual licenses, one for the hardware and gateware, one for the software and one for the documentation.

The hardware and gateware are licensed under the [CERN-OHL-S](https://ohwr.org/cern_ohl_s_v2.txt), the license for which can be found in [LICENSE.hardware](LICENSE.hardware) and [LICENSE.gateware](LICENSE.gateware).

The software is licensed under the BSD-3-Clause and can be found in [LICENSE.software](LICENSE.software).

The documentation is licensed under the Creative Commons [CC-BY-SA](https://creativecommons.org/licenses/by-sa/2.0/) and can be found in [LICENSE.docs](LICENSE.docs)

## KiCad design hardware/boards/host_card/lethallink.kicad_pcb

Parts:
FB1, FB2, FB3, FB4, FB5, FB6, FB7, FB8, FB9: 33 @ 100Mhz; R_0402_1005Metric; MPN BLM15PX330SN1D
J1: PCIe-x4; PCIe-x4-Card-FH

Connections:
+3.3VA: FB3.1; also elsewhere on the board
+3V3: FB7.1, FB8.1, FB9.1; also elsewhere on the board
+12V: FB1.1, FB2.1, FB4.1, FB5.1, FB6.1; also elsewhere on the board
/AUX Control/CLKREQ#: J1.B12 (CLKREQ#); also elsewhere on the board
/AUX Control/PCIe_SMCLK: J1.B5 (SMCLK); also elsewhere on the board
/AUX Control/PCIe_SMDAT: J1.B6 (SMDAT); also elsewhere on the board
/AUX Control/PCIe_TCK: J1.A5 (TCK); also elsewhere on the board
/AUX Control/PCIe_TDI: J1.A6 (TDI); also elsewhere on the board
/AUX Control/PCIe_TDO: J1.A7 (TDO); also elsewhere on the board
/AUX Control/PCIe_TMS: J1.A8 (TMS); also elsewhere on the board
/AUX Control/PCIe_TRST#: J1.B9 (TRST#); also elsewhere on the board
/AUX Control/PERST#: J1.A11 (PERST#); also elsewhere on the board
/AUX Control/WAKE#: J1.B11 (WAKE#); also elsewhere on the board
/PCIe Interface/REFCLK_N: J1.A14 (REFCLK-); also elsewhere on the board
/PCIe Interface/REFCLK_P: J1.A13 (REFCLK+); also elsewhere on the board
/PCIe Interface/RX0_N: J1.A17 (RX0-); also elsewhere on the board
/PCIe Interface/RX0_P: J1.A16 (RX0+); also elsewhere on the board
/PCIe Interface/RX1_N: J1.A23 (RX1-); also elsewhere on the board
/PCIe Interface/RX1_P: J1.A22 (RX1+); also elsewhere on the board
/PCIe Interface/RX2_N: J1.A27 (RX2-); also elsewhere on the board
/PCIe Interface/RX2_P: J1.A26 (RX2+); also elsewhere on the board
/PCIe Interface/RX3_N: J1.A31 (RX3-); also elsewhere on the board
/PCIe Interface/RX3_P: J1.A30 (RX3+); also elsewhere on the board
/PCIe Interface/TX0_N: J1.B15 (TX0-); also elsewhere on the board
/PCIe Interface/TX0_P: J1.B14 (TX0+); also elsewhere on the board
/PCIe Interface/TX1_N: J1.B20 (TX1-); also elsewhere on the board
/PCIe Interface/TX1_P: J1.B19 (TX1+); also elsewhere on the board
/PCIe Interface/TX2_N: J1.B24 (TX2-); also elsewhere on the board
/PCIe Interface/TX2_P: J1.B23 (TX2+); also elsewhere on the board
/PCIe Interface/TX3_N: J1.B28 (TX3-); also elsewhere on the board
/PCIe Interface/TX3_P: J1.B27 (TX3+); also elsewhere on the board
/PRSNT#: J1.A1 (PRSNT1#), J1.B31 (PRSNT2#)
GND: J1.A4 (GND), J1.A12 (GND), J1.A15 (GND), J1.A18 (GND), J1.A20 (GND), J1.A21 (GND), J1.A24 (GND), J1.A25 (GND), J1.A28 (GND), J1.A29 (GND), J1.A32 (GND), J1.B4 (GND), J1.B7 (GND), J1.B13 (GND), J1.B16 (GND), J1.B18 (GND), J1.B21 (GND), J1.B22 (GND), J1.B25 (GND), J1.B26 (GND), J1.B29 (GND), J1.B32 (GND), J1.G1 (GND), J1.G2 (GND); also elsewhere on the board
unnamed: FB1.2, FB2.2, FB4.2, FB5.2, FB6.2, J1.A2 (12V0), J1.A3 (12V0), J1.B1 (12V0), J1.B2 (12V0), J1.B3 (12V0)
unnamed: FB3.2, J1.B10 (3V3_AUX)
unnamed: FB7.2, FB8.2, FB9.2, J1.A9 (3V3), J1.A10 (3V3), J1.B8 (3V3)

Parts:
C59: 0.1uF; C_0603_1608Metric; MPN C0603C104M5RACTU
R56: 100; R_0402_1005Metric; MPN RCS0402100RFKED
U1: ECP5UM5G-381caBGA; 318caBGA; MPN LFE5UM5G-85F-8BG381I; DIGIKEY_PN 220-2112-ND
X1: 100MHz; AX3; MPN AX3DCF1-100.0000

Connections:
+1V8: C59.2, X1.1 (OE), X1.6 (VCC); also elsewhere on the board
/External Interface/CLK+: R56.1, U1.B11 (PT65A), X1.4 (CLK)
/External Interface/CLK-: R56.2, U1.C11 (PT65B), X1.5 (~CLK)
GND: C59.1, X1.3 (GND); also elsewhere on the board

Parts:
J6: SODIMM_260; lethallink_debug_module_mount; MPN 2309413-1
U1: ECP5UM5G-381caBGA; 318caBGA; MPN LFE5UM5G-85F-8BG381I; DIGIKEY_PN 220-2112-ND

Parts:
FID1, FID2, FID3, FID4, FID5, FID6, FID7, FID8, FID9, FID10, FID11, FID12: Fiducial; Fiducial_0.5mm_Mask1mm
G1: Antifaschistische_Aktion; Antifaschistische Aktion_100dpi

Parts:
C23, C24, C25, C26, C27, C33, C37, C40, C47, C49, C50, C52: 10nF; C_0402_1005Metric; MPN C0402C103M5RACTU
C28, C29, C30, C31, C32, C34, C36, C41, C48, C51: 0.1uF; C_0402_1005Metric; MPN C0402C104M8PACTU
C35, C38: 1nF; C_0402_1005Metric; MPN C0402C102K5RACTU
C42, C53, C60, C61, C62, C63, C64, C65, C85, C86, C87, C88, C89: 0.1uF; C_0603_1608Metric; MPN C0603C104M5RACTU
C43, C44, C79, C80: 22uF; C_0805_2012Metric; MPN C0805C226K9PAC7800
C45, C46, C81, C82: 1uF; C_0603_1608Metric; MPN C0603C105K4RACTU
C57, C58: 22uF; C_0805_2012Metric; MPN C0805C226M9PACTU
C84, C90: 4.7uF; C_0603_1608Metric; MPN C0603C475K8PACTU
FB10, FB11, FB12, FB13, FB14: 220 @ 100Mhz; R_0603_1608Metric; MPN BLM18AG221SN1D
J6: SODIMM_260; lethallink_debug_module_mount; MPN 2309413-1
R57: 1k; R_0603_1608Metric; MPN CRCW06031K00FKEAHP
R63: 4K99; R_0603_1608Metric; MPN CRCW06034K99FKEAC
R64: 10K; R_0603_1608Metric; MPN RCS060310K0FKEA
U1: ECP5UM5G-381caBGA; 318caBGA; MPN LFE5UM5G-85F-8BG381I; DIGIKEY_PN 220-2112-ND
U3: CYUSB3014; BGA-121_11x11_10.0x10.0mm; MPN CYUSB3014-BZXI; DIGIKEY_PN 428-3130-ND
U4, U8: IS43TR16256B-125KBL; BGA-96_9.0x13.0mm_Layout2x3x16_P0.8mm; MPN IS43TR16256B-125KBL
U5: 128MiB; WSON-8-1EP-6.0x8.0mm; MPN W25N01GVZEIG TR
U6: 128MiB; WSON-8-1EP-6.0x8.0mm; MPN W25N01GVZEIG
U7: SI5330B; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm; MPN SI5330B-B00205-GM
U9: ADP175X; QFN-16-1EP_4x4mm_P0.65mm_EP2.5x2.5mm; MPN ADP1753

Connections:
+1V2: C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C57.1, C58.1, U1.H8 (VCC), U1.H9 (VCC), U1.H10 (VCC), U1.H11 (VCC), U1.H12 (VCC), U1.H13 (VCC), U1.J8 (VCC), U1.J13 (VCC), U1.K8 (VCC), U1.K13 (VCC), U1.L8 (VCC), U1.L13 (VCC), U1.M8 (VCC), U1.M13 (VCC), U1.N8 (VCC), U1.N9 (VCC), U1.N10 (VCC), U1.N11 (VCC), U1.N12 (VCC), U1.N13 (VCC), U1.T6 (VCCA0), U1.T15 (VCCA1), U1.U6 (VCCA0), U1.U15 (VCCA1), U3.A2 (U3RXVDDQ), U3.A7 (AVDD), U3.B5 (U3RXVDDQ), U3.B10 (VCC), U3.C3 (VCC), U3.E9 (VCC), U3.F11 (VCC), U3.H1 (VCC), U3.J11 (VCC), U3.L5 (VCC), U3.L7 (VCC); also elsewhere on the board
+1V5: C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, FB11.2, FB12.2, FB13.2, FB14.2, U1.H14 (VCCIO2), U1.H15 (VCCIO2), U1.J15 (VCCIO2), U1.L14 (VCCIO3), U1.L15 (VCCIO3), U1.M15 (VCCIO3); also elsewhere on the board
+1V8: C60.1, C61.1, C62.2, C63.2, C64.2, C65.2, R57.2, U1.H6 (VCCIO7), U1.H7 (VCCIO7), U1.J6 (VCCIO7), U3.B6 (CVDDQ), U3.E3 (VIO3), U3.F1 (VIO2), U3.H11 (VIO1), U3.L9 (VIO1), U7.7 (VCC), U7.11 (VCCO3), U7.15 (VCCO2), U7.16 (VCCO1), U7.20 (VCCO0), U7.24 (VCC); also elsewhere on the board
+3V3: C40.1, C41.1, C42.2, C53.2, C84.1, U1.P9 (VCCIO8), U1.P10 (VCCIO8), U3.B1 (VIO4), U3.C11 (VIO5), U5.8 (VCC), U6.8 (VCC), U9.1 (VIN), U9.2 (VIN), U9.3 (VIN), U9.4 (EN), U9.15 (VIN), U9.16 (VIN); also elsewhere on the board
/IC Power/VBUS: FB10.2; also elsewhere on the board
/IC Power/_0V75: C86.1, C87.1, C88.2, C89.2, C90.2, R63.2, U4.H1 (VREFDQ), U4.M8 (VREFCA), U8.H1 (VREFDQ), U8.M8 (VREFCA), U9.10 (VOUT), U9.11 (VOUT), U9.12 (VOUT), U9.13 (VOUT), U9.14 (VOUT)
GND: C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C40.2, C41.2, C42.1, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.1, C57.2, C58.2, C60.2, C61.2, C62.1, C63.1, C64.1, C65.1, C79.2, C80.2, C81.2, C82.2, C84.2, C85.2, C86.2, C87.2, C88.1, C89.1, C90.1, R64.1, U1.B7 (GND), U1.B14 (GND), U1.C19 (GND), U1.D4 (GND), U1.F7 (GND), U1.F8 (GND), U1.F13 (GND), U1.F14 (GND), U1.G4 (GND), U1.G6 (GND), U1.G7 (GND), U1.G8 (GND), U1.G9 (GND), U1.G10 (GND), U1.G11 (GND), U1.G12 (GND), U1.G13 (GND), U1.G14 (GND), U1.G15 (GND), U1.G17 (GND), U1.H19 (GND), U1.J2 (GND), U1.J7 (GND), U1.J9 (GND), U1.J10 (GND), U1.J11 (GND), U1.J12 (GND), U1.J14 (GND), U1.K6 (GND), U1.K7 (GND)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; also elsewhere on the board
unnamed: C43.1, C45.1, C46.1, C80.1, FB11.1, FB12.1, U4.A1 (VDDQ), U4.A8 (VDDQ), U4.B2 (VDD), U4.C1 (VDDQ), U4.C9 (VDDQ), U4.D2 (VDDQ), U4.D9 (VDD), U4.E9 (VDDQ), U4.F1 (VDDQ), U4.G7 (VDD), U4.H2 (VDDQ), U4.H9 (VDDQ), U4.K2 (VDD), U4.K8 (VDD), U4.N1 (VDD), U4.N9 (VDD), U4.R1 (VDD), U4.R9 (VDD)
unnamed: C44.1, C79.1, C81.1, C82.1, FB13.1, FB14.1, U8.A1 (VDDQ), U8.A8 (VDDQ), U8.B2 (VDD), U8.C1 (VDDQ), U8.C9 (VDDQ), U8.D2 (VDDQ), U8.D9 (VDD), U8.E9 (VDDQ), U8.F1 (VDDQ), U8.G7 (VDD), U8.H2 (VDDQ), U8.H9 (VDDQ), U8.K2 (VDD), U8.K8 (VDD), U8.N1 (VDD), U8.N9 (VDD), U8.R1 (VDD), U8.R9 (VDD)
unnamed: C85.1, U9.7 (SS)
unnamed: FB10.1, U3.E10 (VBATT), U3.E11 (VBUS)
unnamed: R57.1, U7.8 (LOS)
unnamed: R63.1, R64.2, U9.9 (ADJ)
unnamed: U1.F9 (VCCIO0), U1.F10 (VCCIO0)
unnamed: U1.F11 (VCCIO1), U1.F12 (VCCIO1)
unnamed: U1.F6 (VCCAUX), U1.F15 (VCCAUX), U1.P6 (VCCAUX), U1.P15 (VCCAUX)
unnamed: U1.L6 (VCCIO6), U1.L7 (VCCIO6), U1.M6 (VCCIO6)
unnamed: U1.V10 (VCCAUXA0), U1.V11 (VCCAUXA0)
unnamed: U1.V17 (VCCAUXA1), U1.V18 (VCCAUXA1)

Notes on the sheet:
PLACE NEAR P9
PLACE NEAR P10
Bank 8 (Configuration) Runs on 3v3 logic
TODO: Properly add the rest of the bypass caps for the rest of the IO banks.
TODO: Add the appropriate voltage levels for each bank

Parts:
C1, C2, C4, C5: 10uF; C_1206_3216Metric; MPN C1206C106K3PACTU
C3, C12: 1uF; C_0603_1608Metric; MPN C0603C105K4RACTU
C6, C10, C18, C20: 10pF; C_0603_1608Metric; MPN C0603C100K5RAC7867
C7: 330pF; C_0603_1608Metric; MPN C0603C331J5RACTU
C8, C13, C15, C16: 0.1uF; C_0603_1608Metric; MPN C0603C104M5RACTU
C9, C14, C21, C22: 22uF; C_1206_3216Metric; MPN C1206C226K9PACTU
C11: 470pF; C_0603_1608Metric; MPN C0603C471J5RACTU
C17: 2.2nF; C_0603_1608Metric; MPN C0603C222J3RACTU
C19: 1.8nF; C_0603_1608Metric; MPN C0603C182J5RACTU
D1, D2, D3, D4, D5, D6, D7: GRN; LED_0603_1608Metric; MPN 150060GS75000
L1: 8.2uH; L_Coilcraft_XxL4040; MPN XAL4040-822MEC
L2: 6.8uH; L_Coilcraft_XxL4030; MPN XAL4030-682MEC
L3: 3.3uH; L_Coilcraft_XxL4020; MPN XFL4020-332MEC
L4: 4.7uH; L_Coilcraft_XxL4020; MPN XFL4020-472MEC
Q1, Q2, Q3, Q4: Q_NMOS_GSD; SOT-23; MPN DMN65D8L-7
Q5: SI7232DN-T1-GE3; Si7232DN; MPN SI7232DN-T1-GE3
R1, R2, R31, R32, R33, R34: 20; R_0603_1608Metric; MPN CRCW060320R0JNEA
R3: 1k74; R_0603_1608Metric; MPN CRCW06031K74FKEA
R4: 24k9; R_0603_1608Metric; MPN CRCW060324K9FKEAC
R5: 21k; R_0603_1608Metric; MPN CRCW060321K0FKEAHP
R6, R13, R23, R24: 10K; R_0603_1608Metric; MPN RCS060310K0FKEA
R7: 21k1; R_0603_1608Metric; MPN CRCW060322K1FKEAHP
R10, R15, R19, R20: 10k; R_0603_1608Metric; MPN RCS060310K0FKEA
R11, R14: 12k1; R_0603_1608Metric; MPN CRCW060312K1FKEAHP
R12: 15k; R_0603_1608Metric; MPN CRCW060315K0FKEAHP
R16, R22: 8k2; R_0603_1608Metric; MPN RCS06038K20FKEA
R17: 127k; R_0603_1608Metric; MPN CRCW0603127KFKEAHP
R18, R21: 4k99; R_0603_1608Metric; MPN RCS06034K99FKEA
R25: 3k3; R_0603_1608Metric; MPN CRCW06033K30FKEAHP
R26: 4k22; R_0603_1608Metric; MPN CRCW06034K22FKEAHP
R27, R28, R29, R30: 10k; R_0603_1608Metric; MPN CRCW060310K0FKEA
TP1: 12v0; TestPoint_Pad_D1.0mm
TP2: 3v3; TestPoint_Pad_D1.0mm
TP3: 3v3 Aux; TestPoint_Pad_D1.0mm
TP4: 2v5; TestPoint_Pad_D1.0mm
TP5: 1v8; TestPoint_Pad_D1.0mm
TP6: 1v2; TestPoint_Pad_D1.0mm
TP7: 1v5; TestPoint_Pad_D1.0mm
U2: ADP5050ACPZ-R7; QFN-48_EP_7x7_Pitch0.5mm; MPN ADP5050ACPZ-R7

Connections:
+1V2: C21.1, L3.2, R18.1, R21.2, R28.1, TP6.1; also elsewhere on the board
+1V5: C22.1, L4.2, R16.1, R22.2, R30.1, TP7.1; also elsewhere on the board
+1V8: C14.2, L2.1, R11.1, R14.1, R27.1, TP5.1; also elsewhere on the board
+2V5: C9.2, L1.1, R7.1, R29.1, TP4.1
+3.3VA: R1.1, TP3.1; also elsewhere on the board
+3V3: R2.1, R31.1, R32.1, R33.1, R34.1, TP2.1; also elsewhere on the board
+12V: C1.2, C2.2, C4.2, C5.2, R3.1, R17.1, TP1.1, U2.4 (PVIN_3), U2.9 (PVIN_4), U2.24 (PVIN_2[0]), U2.25 (PVIN_2[1]), U2.35 (PVIN_1[1]), U2.36 (PVIN_1[0]); also elsewhere on the board
GND: C1.1, C2.1, C3.2, C4.1, C5.1, C6.2, C7.1, C9.1, C10.2, C11.1, C12.1, C14.1, C17.1, C18.2, C19.1, C20.2, C21.2, C22.2, D1.1 (K), D2.1 (K), D3.1 (K), Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.1 (S), Q5.4 (S), R4.2, R6.2, R10.1, R13.1, R15.1, R19.2, R20.1, R23.1, R24.2, U2.2 (GND), U2.5 (EN_5), U2.6 (FB_5), U2.7 (VOUT_5), U2.8 (PVIN_5), U2.11 (GND), U2.30 (GND), U2.38 (SS12), U2.43 (SYNC/MODE), U2.47 (SS34), U2.49 (GND); also elsewhere on the board
unnamed: C3.1, U2.44 (VREG)
unnamed: C6.1, R5.1, U2.15 (COMP_4)
unnamed: C7.2, R5.2
unnamed: C8.1, L1.2, U2.10 (SW_4)
unnamed: C8.2, U2.12 (BST_4)
unnamed: C10.1, R12.1, U2.46 (COMP_3)
unnamed: C11.2, R12.2
unnamed: C12.2, U2.42 (VDD)
unnamed: C13.1, L2.2, U2.3 (SW_3)
unnamed: C13.2, U2.1 (BST_3)
unnamed: C15.1, U2.32 (BST_1)
unnamed: C15.2, L3.1, Q5.3 (D), U2.33 (SW_1[1]), U2.34 (SW_1[0])
unnamed: C16.1, U2.28 (BST_2)
unnamed: C16.2, L4.1, Q5.6 (D), U2.26 (SW_2[1]), U2.27 (SW_2[0])
unnamed: C17.2, R25.1
unnamed: C18.1, R25.2, U2.39 (COMP_1)
unnamed: C19.2, R26.1
unnamed: C20.1, R26.2, U2.22 (COMP_2)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.1 (K), Q4.3 (D)
unnamed: D4.2 (A), R34.2
unnamed: D5.1 (K), Q1.3 (D)
unnamed: D5.2 (A), R31.2
unnamed: D6.1 (K), Q2.3 (D)
unnamed: D6.2 (A), R32.2
unnamed: D7.1 (K), Q3.3 (D)
unnamed: D7.2 (A), R33.2
unnamed: Q1.1 (G), R29.2
unnamed: Q2.1 (G), R27.2
unnamed: Q3.1 (G), R28.2
unnamed: Q4.1 (G), R30.2
unnamed: Q5.2 (G), U2.29 (DL2)
unnamed: Q5.5 (G), U2.31 (DL1)
unnamed: R4.1, U2.41 (RT)
unnamed: R6.1, R7.2, U2.16 (FB_4)
unnamed: R10.2, R11.2, U2.14 (EN_4)
unnamed: R13.2, R14.2, U2.45 (FB_3)
unnamed: R15.2, R16.2, U2.48 (EN_3)
unnamed: R17.2, R19.1, U2.37 (EN_1)
unnamed: R18.2, R20.2, U2.23 (EN_2)
unnamed: R21.1, R23.2, U2.40 (FB_1)
unnamed: R22.1, R24.1, U2.21 (FB_2)
